# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Code\App\DataType;..\Code\App\Main;..\Code\ARM\NVIC;..\Code\ARM\System;..\Code\ARM\Systick;..\Code\FW\inc;..\Code\FW\src;..\Code\HW\RCC;..\Code\HW\Timer;..\Code\HW\USART;..\Code\App\OLED;..\Code\App\LED;..\Code\OS\FreeRTOS\include;..\Code\OS\FreeRTOS\portable\RVDS\ARM_CM3;..\Code\HW\USART;..\Code\App\FreeRTOS_Demo;..\Code\App\KeyOne;..\Code\App\ProcKeyOne
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../Code/App/DataType/: DataType.h
    ../Code/App/Main/: Config.h Main.c
    ../Code/App/OLED/: OLED.c
    ../Code/App/LED/: LED.c
    ../Code/App/FreeRTOS_Demo/: FreeRTOS_Demo.c
    ../Code/App/KeyOne/: KeyOne.c
  group HW
    ../Code/HW/Timer/: Timer.c
    ../Code/HW/USART/: UART1.c Queue_Uart.c
  group FW
    ../Code/FW/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../Code/FW/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ARM
    ../Code/ARM/System/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h sys.c
    ../Code/ARM/Systick/: SysTick.c
  group OS/FreeRTOS_CORE
    ../Code/OS/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group OS/FreeRTOS_Portable
    ../Code/OS/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Code/OS/FreeRTOS/portable/MemMang/: heap_4.c
